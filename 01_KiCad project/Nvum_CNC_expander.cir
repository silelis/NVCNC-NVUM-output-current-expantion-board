.title KiCad schematic
H1 GNDD MountingHole_Pad
H2 GNDD MountingHole_Pad
H3 GNDD MountingHole_Pad
H4 GNDD MountingHole_Pad
B1 Net-_B1-Pad1_ +24V GNDD +12V DC-DC stepdown 12V0
J11 GNDD Net-_D21-Pad2_ PS
J12 Net-_J12-Pad1_ Net-_J12-Pad2_ Net-_J12-Pad3_ Net-_J12-Pad4_ Net-_J12-Pad5_ Net-_J12-Pad6_ Net-_J12-Pad7_ Net-_J12-Pad8_ Net-_J12-Pad9_ Net-_J12-Pad10_ Conn_01x10_Male
J1 Net-_D1-Pad1_ GNDD Conn_01x02_Female
D21 Net-_D21-Pad1_ Net-_D21-Pad2_ 1N4001
D22 Net-_D21-Pad1_ Net-_D21-Pad2_ 1N4001
D23 Net-_D21-Pad1_ Net-_D21-Pad2_ 1N4001
D24 Net-_D21-Pad1_ Net-_D21-Pad2_ 1N4001
D25 +24V Net-_D21-Pad1_ 1N4001
D26 +24V Net-_D21-Pad1_ 1N4001
D27 +24V Net-_D21-Pad1_ 1N4001
D28 +24V Net-_D21-Pad1_ 1N4001
R41 +24V Net-_B1-Pad1_ 100k
R31 Net-_J12-Pad1_ /Input_1 1k
R32 Net-_J12-Pad2_ /Input_2 1k
R33 Net-_J12-Pad3_ /Input_3 1k
R34 Net-_J12-Pad4_ /Input_4 1k
R35 Net-_J12-Pad5_ /Input_5 1k
R36 Net-_J12-Pad6_ /Input_6 1k
R37 Net-_J12-Pad7_ /Input_7 1k
R38 Net-_J12-Pad8_ /Input_8 1k
R39 Net-_J12-Pad9_ /Input_9 1k
R40 Net-_J12-Pad10_ /Input_10 1k
R21 +12V /Input_1 100k
R22 +12V /Input_2 100k
R23 +12V /Input_3 100k
R24 +12V /Input_4 100k
R25 +12V /Input_5 100k
R26 +12V /Input_6 100k
R27 +12V /Input_7 100k
R28 +12V /Input_8 100k
R29 +12V /Input_9 100k
R30 +12V /Input_10 100k
D1 Net-_D1-Pad1_ GNDD 1N4001
R1 Net-_Q1-Pad3_ Net-_D1-Pad1_ 60
Q1 /Input_1 +12V Net-_Q1-Pad3_ BC807
D6 GNDD Net-_D6-Pad2_ LED
R6 Net-_D1-Pad1_ Net-_D6-Pad2_ 1500
J2 Net-_D2-Pad1_ GNDD Conn_01x02_Female
D2 Net-_D2-Pad1_ GNDD 1N4001
R2 Net-_Q2-Pad3_ Net-_D2-Pad1_ 60
Q2 /Input_2 +12V Net-_Q2-Pad3_ BC807
D7 GNDD Net-_D7-Pad2_ LED
R7 Net-_D2-Pad1_ Net-_D7-Pad2_ 1500
J3 Net-_D3-Pad1_ GNDD Conn_01x02_Female
D3 Net-_D3-Pad1_ GNDD 1N4001
R3 Net-_Q3-Pad3_ Net-_D3-Pad1_ 60
Q3 /Input_3 +12V Net-_Q3-Pad3_ BC807
D8 GNDD Net-_D8-Pad2_ LED
R8 Net-_D3-Pad1_ Net-_D8-Pad2_ 1500
J4 Net-_D4-Pad1_ GNDD Conn_01x02_Female
D4 Net-_D4-Pad1_ GNDD 1N4001
R4 Net-_Q4-Pad3_ Net-_D4-Pad1_ 60
Q4 /Input_4 +12V Net-_Q4-Pad3_ BC807
D9 GNDD Net-_D9-Pad2_ LED
R9 Net-_D4-Pad1_ Net-_D9-Pad2_ 1500
J5 Net-_D5-Pad1_ GNDD Conn_01x02_Female
D5 Net-_D5-Pad1_ GNDD 1N4001
Q5 /Input_5 +12V Net-_Q5-Pad3_ BC807
D10 GNDD Net-_D10-Pad2_ LED
R10 Net-_D5-Pad1_ Net-_D10-Pad2_ 1500
J6 Net-_D11-Pad1_ GNDD Conn_01x02_Female
D11 Net-_D11-Pad1_ GNDD 1N4001
R11 Net-_Q6-Pad3_ Net-_D11-Pad1_ 60
Q6 /Input_6 +12V Net-_Q6-Pad3_ BC807
D16 GNDD Net-_D16-Pad2_ LED
R16 Net-_D11-Pad1_ Net-_D16-Pad2_ 1500
J8 Net-_D13-Pad1_ GNDD Conn_01x02_Female
D13 Net-_D13-Pad1_ GNDD 1N4001
R13 Net-_Q8-Pad3_ Net-_D13-Pad1_ 60
Q8 /Input_8 +12V Net-_Q8-Pad3_ BC807
D18 GNDD Net-_D18-Pad2_ LED
R18 Net-_D13-Pad1_ Net-_D18-Pad2_ 1500
J9 Net-_D14-Pad1_ GNDD Conn_01x02_Female
D14 Net-_D14-Pad1_ GNDD 1N4001
R14 Net-_Q9-Pad3_ Net-_D14-Pad1_ 60
Q9 /Input_9 +12V Net-_Q9-Pad3_ BC807
D19 GNDD Net-_D19-Pad2_ LED
R19 Net-_D14-Pad1_ Net-_D19-Pad2_ 1500
J10 Net-_D15-Pad1_ GNDD Conn_01x02_Female
D15 Net-_D15-Pad1_ GNDD 1N4001
R15 Net-_Q10-Pad3_ Net-_D15-Pad1_ 60
Q10 /Input_10 +12V Net-_Q10-Pad3_ BC807
D20 GNDD Net-_D20-Pad2_ LED
R20 Net-_D15-Pad1_ Net-_D20-Pad2_ 1500
J7 Net-_D12-Pad1_ GNDD Conn_01x02_Female
D12 Net-_D12-Pad1_ GNDD 1N4001
R12 Net-_Q7-Pad3_ Net-_D12-Pad1_ 60
Q7 /Input_7 +12V Net-_Q7-Pad3_ BC807
D17 GNDD Net-_D17-Pad2_ LED
R17 Net-_D12-Pad1_ Net-_D17-Pad2_ 1500
C1 +12V GNDD 100nF
C2 +12V GNDD 470uF
D29 Net-_D21-Pad1_ Net-_D21-Pad2_ 1N4001
D30 +24V Net-_D21-Pad1_ 1N4001
R5 Net-_Q5-Pad3_ Net-_D5-Pad1_ 60
D31 NC_01 NC_02 DIODE
.end
